# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\Delay;C:\Keil_v5\C51\INC\Atmel
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Hardware/: Nixie.c MatrixKey.c
    ./Delay/: Delay.c
