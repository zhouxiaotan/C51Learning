# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\10-2 定时器按键控制LED流水灯;.\Delay
  group Source Group 1
    ./: STARTUP.A51 main.c Timer.c key.c
    ./Delay/: Delay.c
